# IAR project SmarTag2.ewp, settings and files
configuration SmarTag2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4P5CG ST STM32L4P5CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4P5xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers\BSP\SmarTag2; ../../../../../Drivers\BSP\Components\lps22df; ../../../../../Drivers\BSP\Components\lsm6dso32x; ../../../../../Drivers\BSP\Components\st25dvxxkc; ../../../../../Drivers\BSP\Components\stts22h; ../../../../../Drivers\BSP\Components\vd6283tx\modules; ../../../../../Drivers\BSP\Components\vd6283tx\porting; ../../../../../Drivers\BSP\Components\vd6283tx; ../../../../../Drivers\BSP\Components\lis2duxs12; ../../../../../Drivers\BSP\Components\Common; ../STSmartNFC\Inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SmarTag2.bin
  ILINK.IlinkOutputFile: SmarTag2.out
  ILINK.IlinkIcfFile: stm32l4p5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l4p5xx.s
  group Application/User
    ../Src/: AppSmarTag.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Application/User/STSmartNFC
    ../STSmartNFC/Src/: SmartNFC.c TagType5.c
  group Drivers/BSP/Components/lis2duxs12
    ../../../../../Drivers/BSP/Components/lis2duxs12/: lis2duxs12.c lis2duxs12_reg.c
  group Drivers/BSP/Components/lsm6dso32x
    ../../../../../Drivers/BSP/Components/lsm6dso32x/: lsm6dso32x.c lsm6dso32x_reg.c
  group Drivers/BSP/Components/lsp22df
    ../../../../../Drivers/BSP/Components/lps22df/: lps22df.c lps22df_reg.c
  group Drivers/BSP/Components/st25dvxxkc
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc.c st25dvxxkc_reg.c
  group Drivers/BSP/Components/stts22h
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/Components/vd6283
    ../../../../../Drivers/BSP/Components/vd6283tx/porting/: platform.c
    ../../../../../Drivers/BSP/Components/vd6283tx/modules/: VD6283.c
    ../../../../../Drivers/BSP/Components/vd6283tx/: vd6283tx.c
  group Drivers/BSP/SMARTAG2
    ../../../../../Drivers/BSP/SmarTag2/: SmarTag2.c SmarTag2_bus.c SmarTag2_env_sensors.c SmarTag2_env_sensors_ex.c Smartag2_light_sensor.c SmarTag2_motion_sensors.c SmarTag2_motion_sensors_ex.c SmarTag2_nfctag.c SmarTag2_nfctag_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c

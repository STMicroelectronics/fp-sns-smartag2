# IAR project SimpleBootLoader.ewp, settings and files
configuration SimpleBootLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4P5CG ST STM32L4P5CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4P5xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimpleBootLoader.bin
  ILINK.IlinkOutputFile: SimpleBootLoader.out
  ILINK.IlinkIcfFile: stm32l4p5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l4p5xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c

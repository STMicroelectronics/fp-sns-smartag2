# Keil uVision project SimpleBootLoader.uvprojx, settings and files
target SimpleBootLoader (6180000::V6.18::ARMCLANG)
  device: STM32L4P5CGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08000000-0x8003BFF) IRAM(0x20000000-0x2004FFFF) IRAM2(0x20000000-0x2001FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SimpleBootLoader +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L4P5xx
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l4p5xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c
software components: CMSIS:CORE 5.6.0

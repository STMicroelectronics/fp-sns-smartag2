# Keil uVision project FirmwareUpdate.uvprojx, settings and files
target FirmwareUpdate (6180000::V6.18::ARMCLANG)
  device: STM32L4P5CGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IROM(0x08002000-0x807FFFF) IRAM(0x20000000-0x2004FFFF) IRAM2(0x20000000-0x2001FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FirmwareUpdate +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L4P5xx
  c misc: -Wno-format -Wno-enum-conversion
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/SmarTag2;../../../../../Drivers/BSP/Components/st25dvxxkc;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/ST25FTM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x7e000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l4p5xx.s
  group Application/User
    ../Src/: flashl4_if.c ftm_process.c fw_command.c logger.c main.c st25ftm_config.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc.c st25dvxxkc_reg.c
  group Drivers/BSP/SMARTAG2
    ../../../../../Drivers/BSP/SmarTag2/: SmarTag2.c SmarTag2_bus.c SmarTag2_nfctag.c SmarTag2_nfctag_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/ST25FTM
    ../../../../../Middlewares/ST/ST25FTM/Src/: st25ftm_common.c st25ftm_protocol.c st25ftm_rx.c st25ftm_tx.c
software components: CMSIS:CORE 5.6.0

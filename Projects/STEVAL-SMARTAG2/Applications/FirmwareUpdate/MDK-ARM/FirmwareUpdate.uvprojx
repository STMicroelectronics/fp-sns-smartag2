# Keil uVision project FirmwareUpdate.uvprojx, settings and files
target FirmwareUpdate (6180000::V6.18::ARMCLANG)
  device: STM32L4P5CGUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FirmwareUpdate +hex
  AfterMake: fromelf #L --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32L4P5xx
  c misc: -Wno-format -Wno-enum-conversion
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/SmarTag2;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/ST25FTM/Inc;../../../../../Drivers/BSP/Components/st25dvxxkc;../../../../../Drivers/BSP/Components/vd6283tx/modules;../../../../../Drivers/BSP/Components/vd6283tx/porting;../../../../../Drivers/BSP/Components/vd6283tx;../../../../../Drivers/BSP/Components/lsm6dso32x;../../../../../Drivers/BSP/Components/lps22df;../../../../../Drivers/BSP/Components/h3lis331dl;../../../../../Drivers/BSP/Components/stts22h;../../../../../Drivers/BSP/Components/lis2duxs12
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x7e000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l4p5xx.s
  group Application/User
    ../Src/: main.c flashl4_if.c fw_command.c logger.c st25ftm_config.c st25ftm_process.c app_firmwareupdate.c steval_smartag2_bus.c steval_smartag2.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/SmarTag2
    ../../../../../Drivers/BSP/SmarTag2/: SmarTag2_env_sensors.c SmarTag2_env_sensors_ex.c Smartag2_light_sensor.c SmarTag2_motion_sensors.c SmarTag2_motion_sensors_ex.c SmarTag2_nfctag.c SmarTag2_nfctag_ex.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st25dvxxkc/: st25dvxxkc_reg.c st25dvxxkc.c
    ../../../../../Drivers/BSP/Components/vd6283tx/modules/: VD6283.c
    ../../../../../Drivers/BSP/Components/vd6283tx/porting/: platform.c
    ../../../../../Drivers/BSP/Components/vd6283tx/: vd6283tx.c
    ../../../../../Drivers/BSP/Components/lsm6dso32x/: lsm6dso32x_reg.c lsm6dso32x.c
    ../../../../../Drivers/BSP/Components/lps22df/: lps22df_reg.c lps22df.c
    ../../../../../Drivers/BSP/Components/h3lis331dl/: h3lis331dl_reg.c h3lis331dl.c
    ../../../../../Drivers/BSP/Components/stts22h/: stts22h_reg.c stts22h.c
    ../../../../../Drivers/BSP/Components/lis2duxs12/: lis2duxs12_reg.c lis2duxs12.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/ST25FTM/Data Exchange/ST25FTM
    ../../../../../Middlewares/ST/ST25FTM/Src/: st25ftm_common.c st25ftm_protocol.c st25ftm_rx.c st25ftm_tx.c
software components: CMSIS:CORE 5.6.0
